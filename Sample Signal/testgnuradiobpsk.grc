options:
  parameters:
    author: Sam
    generate_options: qt_gui
    id: testgnuradiobpsk
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1600000'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\Sam\Documents\Senior Design Project\Sample Signal\sampleData2.wav
    repeat: 'False'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: satellites_bpsk_demodulator_0
  id: satellites_bpsk_demodulator
  parameters:
    baudrate: '80000'
    differential: 'False'
    f_offset: '0'
    manchester: 'False'
    samp_rate: samp_rate
  states: {}

connections:
- [blocks_throttle2_0, '0', satellites_bpsk_demodulator_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle2_0, '0']
- [satellites_bpsk_demodulator_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
